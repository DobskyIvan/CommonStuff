# Keil uVision project example.uvprojx, settings and files
target Device (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\Startup;.\System;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\MemMang
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group System
    ./System/: system_stm32f10x.c
  group FreeRTOS
    ./FreeRTOS/: FreeRTOSConfig.h list.c port.c queue.c tasks.c
    ./FreeRTOS/MemMang/: heap_1.c
